SRC_URI = "git://github.com/xroumegue/qemu-devicetrees.git;protocol=https;branch=xlnx_rel_v2023.1-cosim"
SRCREV = "${AUTOREV}"
PV = "xlnx_rel_v2023.1-cosim+git${SRCPV}"

