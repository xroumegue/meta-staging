SRC_URI = "git://gitlab.com/ideasonboard/nxp/yavta.git;protocol=https;branch=master"
SRCREV = "${AUTOREV}"
PV = "master+git${SRCPV}"
