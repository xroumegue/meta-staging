COMPATIBLE_MACHINE:append = "|genericarm64"
